Commit message: Update Sanity inertial model with reproducible bifilar measurements

File: models/sanity.urdf (robot description, URDF)
Before this commit: robot sanity, 5 links, 4 joints
Links:
- link base_link: mass 0.06609 -> 0.06947
